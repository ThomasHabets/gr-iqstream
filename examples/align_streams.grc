options:
  parameters:
    id: alignment_grc
    title: Align Real and Complex Streams
    generate_options: no_gui
    output_language: python
    run: 'False'
  states: {}

blocks:
- name: pmt_import
  id: import
  parameters:
    imports: |-
      import pmt
      from gnuradio import gr
  states: {}
- name: first
  id: blocks_vector_source_x
  parameters:
    type: float
    vector: list(range(10))
    repeat: 'False'
    tags: '[gr.tag_utils.python_to_tag([0, pmt.intern(''rustradio.iq.absolute_sample_index''), pmt.from_uint64(100), pmt.PMT_F])]'
  states: {}
- name: second
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: '[complex(i, -i) for i in range(10)]'
    repeat: 'False'
    tags: '[gr.tag_utils.python_to_tag([0, pmt.intern(''rustradio.iq.absolute_sample_index''), pmt.from_uint64(102), pmt.PMT_F])]'
  states: {}
- name: aligned
  id: iqstream_align_streams
  parameters:
    type0: float
    type1: complex
  states: {}
- name: out0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: out1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [first, '0', aligned, '0']
- [second, '0', aligned, '1']
- [aligned, '0', out0, '0']
- [aligned, '1', out1, '0']

metadata:
  file_format: 1
